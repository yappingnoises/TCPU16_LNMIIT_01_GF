VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO my_logo
  CLASS BLOCK ;
  FOREIGN my_logo 0.000 0.000 ;
  ORIGIN 0.000 0.000 ;
  SIZE 115.700 BY 115.050 ;
END my_logo

END LIBRARY
